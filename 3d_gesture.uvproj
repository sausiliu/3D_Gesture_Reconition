# Keil uVision project 3d_gesture.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: RTOSDemo
  c flags: Optim=1 uC99=1
  c define: RVDS_ARMCM3_LM3S102
  c include: .\Source;.\Source\User;.\Source\FreeRTOS\include;.\Source\Common\include;.\Source\User\STM32F10xFWLib\inc;.\Source\User\driver\inc;.\Source\core\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group FreeRTOS files
    ./Source/FreeRTOS/: tasks.c queue.c list.c
    ./Source/FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ./Source/FreeRTOS/portable/MemMang/: heap_2.c
  group SystemLib
    ./Source/User/: STM32F10x.s
    ./Source/Common/drivers/ST/STM32F10xFWLib/src/: cortexm3_macro_rvds.s
    ./Source/User/STM32F10xFWLib/src/: stm32f10x_usart.c stm32f10x_gpio.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_i2c.c stm32f10x_exti.c
  group Driver
    ./Source/User/driver/src/: serial.c
    ./Source/User/driver/src/i2c/: i2c.c
    ./Source/User/driver/src/sensor/: inv_mpu.c
  group User
    ./Source/User/: timertest.c main.c mpu9150.c
    ./Source/Common/Minimal/: comtest.c death.c
  group core
    ./Source/core/driver/eMPL/: inv_mpu_dmp_motion_driver.c
    ./Source/core/eMPL-hal/: eMPL_outputs.c
    ./Source/core/mllite/: data_builder.c hal_outputs.c message_layer.c ml_math_func.c mlmath.c mpl.c results_holder.c start_manager.c storage_manager.c
    ./Source/core/mpl/: libmpllib.lib
